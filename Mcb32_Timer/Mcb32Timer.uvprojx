# Keil uVision project Mcb32Timer.uvprojx, settings and files
target Mcb32Timer (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x00040000) IRAM(0x20000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Mcb32Timer +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\Sources;.\Templates;.\Libraries\CMSIS\Core;.\Libraries\CMSIS\ST\STM32F10x;.\Libraries\STM32F10x_StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group StartUp
    ./Libraries/CMSIS/ST/STM32F10x/startup/: startup_stm32f10x_cl.s
  group Templates
    ./Templates/: system_stm32f10x.c
  group Sources
    ./Sources/: main.c Ports.c Job.c TimerTicker.c RunLed.c TouchP0P1.lib TimerInt.c
  group STM32F10x_StdPeriph_Driver
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_tim.c
